# Keil uVision project Template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE
  group HARDWARE
    ../HARDWARE/: Delay.c DS18B20.c ESP8266.c LCD1602.c LED.c
  group USER
    ./: main.c
