#include "LED.h"

/*******************************************************
***********   函 数 名 ：flow              *************
***********   功 能    ：实现LED灯流水灯   *************
********************************************************/
void flow(u8 i)
{
	u8 j;
	if(i==1)
	{
		led=0xfe;
		delay1ms(400); //大约延时450ms	
		for(j=0;j<7;j++)	 //将led左移一位
		{
			led=_crol_(led,1);
			
			if(i!=1){j=7;led=0xff;return;}
			delay1ms(400);
			 //大约延时450ms	
		}
		for(j=0;j<7;j++)	//将led右移一位
		{
			led=_cror_(led,1);
			
			if(i!=1){j=7;led=0xff;return;}
			 //大约延时450ms
			delay1ms(400);	
		 }
		 led=0xff;
	}
}
/*******************************************************
***********   函 数 名 ：light             *************
***********   功 能    ：实现点亮LED灯     *************
********************************************************/
void light(u8 i)
{
	if(i==1)
		led&=0x00;
}
/*******************************************************
***********   函 数 名 ：voice             *************
***********   功 能    ：实现蜂鸣器叫      *************
********************************************************/
void voice(u8 i)
{
	u16 j=10000;
	if(i==1)
	{
		while(j--)
		{
			beep=~beep;
			delayus(10);
		}
	}
}

u8 exchange(u8 i)
{
	if(i==0)  return 1;
	else      return 0;
}